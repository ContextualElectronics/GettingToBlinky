# Repository ContextualElectronics/GettingToBlinky

## KiCad design GTB.kicad_pcb

Board: 2 copper layers, 25.4 x 25.4 mm, 7 parts (1 on the bottom side), 6 nets.

Parts:
BT1: CR2032
C1: 1U; SM1206
D1: LED; LED-1206
R1: 470K; SM1206
R2: 1K; SM1206
U1: 7555; SO8N
VR1: LDR; R1

Connections:
GND: BT1.2, C1.2, D1.2, U1.1
unnamed: D1.1, R2.2
unnamed: R2.1, U1.3
unnamed: C1.1, R1.2, U1.2, U1.6
unnamed: R1.1, U1.7, VR1.2
VCC: BT1.1, U1.4, U1.8, VR1.1

## Commit log

2013-10-01 Initial Commit
    Project files, local library for 7555 schematic symbol, schematic and
    layout files.
2013-10-02 Finished Schematic
2013-10-02 Associated most of the symbols with footprints
2013-10-03 Imported Footprints To Layout and Added CR2032 Footprint
2013-10-03 Board Layout of the GTB 1 Sq In PCB
